<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\COM.Apple.HomeKit\EWARM\COM.Apple.HomeKit.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\COM.MXCHIP.HA\EWARM\COM.MXCHIP.HA.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\COM.MXCHIP.SPP\EWARM\COM.MXCHIP.SPP.ewp</path>
  </project>
  <batchBuild/>
</workspace>


