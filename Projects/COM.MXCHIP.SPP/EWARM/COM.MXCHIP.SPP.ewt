<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>EMW3162_Debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>EMW3161_Debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Open1081</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>Application</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\Demos\COM.MXCHIP.SPP\LocalTcpServer.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Demos\COM.MXCHIP.SPP\MICOAppDefine.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Demos\COM.MXCHIP.SPP\MICOAppEntrance.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Demos\COM.MXCHIP.SPP\MICOBonjour.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Demos\COM.MXCHIP.SPP\MICOConfigDelegate.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Demos\NEARAIR\NearAirParaStorage.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Demos\NEARAIR\NearAirProtocol.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Demos\COM.MXCHIP.SPP\RemoteTcpClient.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Demos\COM.MXCHIP.SPP\SppProtocol.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Demos\COM.MXCHIP.SPP\stm32f2xx_it.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Demos\NEARAIR\stringtool.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Demos\COM.MXCHIP.SPP\UartRecv.c</name>
    </file>
  </group>
  <group>
    <name>External</name>
    <group>
      <name>Curve25519</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\External\Curve25519\curve25519-donna.c</name>
      </file>
    </group>
    <group>
      <name>GladmanAES</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\External\GladmanAES\aes_modes.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\External\GladmanAES\aescrypt.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\External\GladmanAES\aeskey.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\External\GladmanAES\aestab.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\External\GladmanAES\gf128mul.c</name>
      </file>
    </group>
    <group>
      <name>JSON-C</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\External\JSON-C\arraylist.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\External\JSON-C\debug.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\External\JSON-C\json.h</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\External\JSON-C\json_object.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\External\JSON-C\json_tokener.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\External\JSON-C\json_util.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\External\JSON-C\linkhash.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\External\JSON-C\printbuf.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>Library</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\Library\MICOConfig.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Library\mxchipWNet_3161.a</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Library\mxchipWNET_3162.a</name>
    </file>
  </group>
  <group>
    <name>MICO</name>
    <group>
      <name>EasyLink</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\MICO\EasyLink\EasyLink.c</name>
      </file>
    </group>
    <group>
      <name>WAC</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\MICO\WAC\MFi_WAC_CortexM3_debug.a</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\MICO\WAC\MFi_WAC_CortexM3_release.a</name>
      </file>
    </group>
    <group>
      <name>WPS</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\MICO\WPS\WPS.c</name>
      </file>
    </group>
    <file>
      <name>$PROJ_DIR$\..\..\..\MICO\MICOConfigMenu.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\MICO\MICOConfigServer.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\MICO\MICODefine.h</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\MICO\MICOEntrance.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\MICO\MICONotificationCenter.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\MICO\MICONTPClient.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\MICO\MICOParaStorage.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\MICO\MICOSystemMonitor.c</name>
    </file>
  </group>
  <group>
    <name>NearAir_Bsp</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\NearAir_Bsp\bsp_adc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\NearAir_Bsp\bsp_beep.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\NearAir_Bsp\bsp_button.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\NearAir_Bsp\bsp_buzzer.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\NearAir_Bsp\bsp_led.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\NearAir_Bsp\bsp_menu.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\NearAir_Bsp\bsp_motor.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\NearAir_Bsp\bsp_nearair.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\NearAir_Bsp\bsp_sensor.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\NearAir_Bsp\bsp_sensor_gp2y1050.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\NearAir_Bsp\bsp_sensor_mhtrd06.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\NearAir_Bsp\bsp_sensor_tgs2600.c</name>
    </file>
  </group>
  <group>
    <name>Platform</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\Platform\platform.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Platform\PlatformFlash.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Platform\PlatformMFiAuth.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Platform\PlatformRandomNumber.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Platform\PlatformRTC.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Platform\PlatformUart.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Platform\PlatformWDG.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Platform\system_stm32f2xx.c</name>
    </file>
  </group>
  <group>
    <name>startup</name>
    <file>
      <name>$PROJ_DIR$\startup_stm32f2xx.s</name>
    </file>
  </group>
  <group>
    <name>STM32_HAL_LIB</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\STM32F2xx_StdPeriph_Driver\src\misc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_adc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_can.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_crc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_cryp.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_cryp_aes.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_cryp_des.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_cryp_tdes.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_dac.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_dbgmcu.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_dcmi.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_dma.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_exti.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_flash.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_fsmc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_gpio.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_hash.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_hash_md5.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_hash_sha1.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_i2c.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_iwdg.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_pwr.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_rcc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_rng.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_rtc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_sdio.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_spi.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_syscfg.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_tim.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_usart.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\STM32F2xx_StdPeriph_Driver\src\stm32f2xx_wwdg.c</name>
    </file>
  </group>
  <group>
    <name>Support</name>
    <file>
      <name>$PROJ_DIR$\..\..\..\Library\support\AESUtils.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Library\support\HTTPUtils.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Library\support\MDNSUtils.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Library\support\RingBufferUtils.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Library\support\SecurityUtils.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Library\support\SHAUtils.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Library\support\SocketUtils.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Library\support\StringUtils.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Library\support\TimeUtils.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Library\support\TLVUtils.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Library\support\URLUtils.c</name>
    </file>
  </group>
</project>


