# IAR project COM.Apple.HomeKit.ewp, settings and files
configuration EMW3162_Debug (ARM)
  General.OGChipSelectEditMenu: STM32F205ZG ST STM32F205ZG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; EMW3162; DEBUG
  ICCARM.CCIncludePath2: ..\..\..\Library\inc; ..\..\..\STM32F2xx_StdPeriph_Driver\inc; ..\..\..\Platform; ..\..\..\Library\support; ..\..\..\MICO; ..\..\..; ..\..\..\Demos\COM.Apple.HomeKit
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: COM.Apple.HomeKit.bin
  ILINK.IlinkOutputFile: COM.Apple.HomeKit.out
  ILINK.IlinkIcfFile: mxchipWNet.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration EMW3161_Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; EMW3161; DEBUG
  ICCARM.CCIncludePath2: ..\..\..\Library\inc; ..\..\..\STM32F2xx_StdPeriph_Driver\inc; ..\..\..\Platform; ..\..\..\Library\support; ..\..\..\Demos\COM.Apple.HomeKit; ..\..\..\MICO; ..\..\..
configuration Open1081 (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; Open1081; DEBUG
  ICCARM.CCIncludePath2: as above
  group Application
    ../../../Demos/COM.Apple.HomeKit/: HomeKitHTTPUtils.c HomeKitPairlist.c HomeKitPairProtocol.c HomekitProfiles.c HomeKitServer.c HomeKitUserInterface.c MICOAppDefine.h MICOAppEntrance.c MICOBonjour.c MICOConfigDelegate.c SppProtocol.c stm32f2xx_it.c UartRecv.c
  group External/Curve25519
    ../../../External/Curve25519/: curve25519-donna.c
  group External/GladmanAES
    ../../../External/GladmanAES/: aes_modes.c aescrypt.c aeskey.c aestab.c gf128mul.c
  group External/HMAC_HKDF
    ../../../External/HMAC_HKDF/: hkdf.c hmac.c sha1.c sha224-256.c sha384-512.c usha.c
  group External/JSON-C
    ../../../External/JSON-C/: arraylist.c debug.c json.h json_object.c json_tokener.c json_util.c linkhash.c printbuf.c
  group Library
    ../../../Library/: MICOConfig.c MICOCrypto_CortexM3.a MICOSRPServer_CortexM3.a mxchipWNet_3161.a mxchipWNET_3162.a
  group MICO
    ../../../MICO/: MICOConfigMenu.c MICOConfigServer.c MICODefine.h MICOEntrance.c MICONotificationCenter.c MICONTPClient.c MICOParaStorage.c MICOSystemMonitor.c
  group MICO/EasyLink
    ../../../MICO/EasyLink/: EasyLink.c
  group MICO/WAC
    ../../../MICO/WAC/: MFi_WAC_CortexM3_debug.a MFi_WAC_CortexM3_release.a
  group Platform
    ../../../Platform/: platform.c PlatformFlash.c PlatformMFiAuth.c PlatformRandomNumber.c PlatformRTC.c PlatformUart.c PlatformWDG.c system_stm32f2xx.c
  group startup
    ./: startup_stm32f2xx.s
  group STM32_HAL_LIB
    ../../../STM32F2xx_StdPeriph_Driver/src/: misc.c stm32f2xx_adc.c stm32f2xx_can.c stm32f2xx_crc.c stm32f2xx_cryp.c stm32f2xx_cryp_aes.c stm32f2xx_cryp_des.c stm32f2xx_cryp_tdes.c stm32f2xx_dac.c stm32f2xx_dbgmcu.c stm32f2xx_dcmi.c stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_flash.c stm32f2xx_fsmc.c stm32f2xx_gpio.c stm32f2xx_hash.c stm32f2xx_hash_md5.c stm32f2xx_hash_sha1.c stm32f2xx_i2c.c stm32f2xx_iwdg.c stm32f2xx_pwr.c stm32f2xx_rcc.c stm32f2xx_rng.c stm32f2xx_rtc.c stm32f2xx_sdio.c stm32f2xx_spi.c stm32f2xx_syscfg.c stm32f2xx_tim.c stm32f2xx_usart.c stm32f2xx_wwdg.c
  group Support
    ../../../Library/support/: AESUtils.c HTTPUtils.c MDNSUtils.c RingBufferUtils.c SecurityUtils.c SHAUtils.c SocketUtils.c StringUtils.c TimeUtils.c TLVUtils.c URLUtils.c
